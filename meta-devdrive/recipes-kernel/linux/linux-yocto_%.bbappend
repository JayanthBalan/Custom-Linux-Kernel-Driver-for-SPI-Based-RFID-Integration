FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://rc522-dts.patch"
